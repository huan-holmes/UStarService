Commit message: null

File: src/ustar_slam/urdf/robotmodel.urdf (robot description, URDF)
Before this commit: robot robotmodel, 6 links, 5 joints
Links:
- removed link head
Joints:
- removed joint tobox
